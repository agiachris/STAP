Commit message: Add object tracker

File: configs/pybullet/envs/assets/franka_panda/franka_panda.urdf (robot description, URDF)
Before this commit: robot franka_panda, 8 links, 7 joints
Links:
- link link7: geometry collision mesh filename=collision/link7.stl; visual mesh filename=visual/link7.dae
